options:
  parameters:
    author: Dom Robinson
    category: Custom
    description: APT to WAV recorder for Raspberry-Noaa -V2
    generate_options: no_gui
    id: rtlsdr_noaa_apt_rx
    output_language: python
    run_options: run
    title: RTLSDR NOAA APT Receiver V1.0.0
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '95000'
  states: {}
- name: fcd_freq
  id: variable
  parameters:
    value: '95300000'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: '"/srv/audio/noaa/capture.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: trans
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: blks2_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '96000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: gr_wavfile_sink_0_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recfile
    format: FORMAT_WAV
    samp_rate: '11025'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '192'
    interp: '441'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: airspy=0,bias=0
    bb_gain0: '20'
    freq0: fcd_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blks2_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', gr_wavfile_sink_0_0_0_0, '0']
- [low_pass_filter_0, '0', blks2_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
