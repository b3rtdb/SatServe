options:
  parameters:
    author: Gary Schafer
    generate_options: no_gui
    id: NoaaAptDemodPll
    output_language: python
    run_options: run
    title: RF Carrier Demod of NOAA APT IQ Signal
  states: {}

blocks:
- name: cf
  id: variable
  parameters:
    value: 137.1e6
  states: {}
- name: recfile
  id: variable
  parameters:
    value: '"/srv/audio/noaa/capture.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '912000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: samp_rate/10/(2*np.pi*20e3)
    gain: samp_rate/10/(2*np.pi*20e3)
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-200e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recfile
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: import numpy as np
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 25e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_BLACKMAN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '15'
    taps: ''
    type: fff
  states: {}
- name: soapy_airspyhf_source_0
  id: soapy_airspyhf_source
  parameters:
    center_freq: cf
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [soapy_airspyhf_source_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
